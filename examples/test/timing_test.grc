<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>range_delay</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>samp_rate / sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>range_freq_offset</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>range_noise</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"Before Time Sync"</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_freq_offset</value></param>
<param><key>label</key><value>f_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-0.1</value></param>
<param><key>stop</key><value>0.1</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>num_tabs</key><value>3</value></param>
<param><key>label0</key><value>Before Sync</value></param>
<param><key>label1</key><value>After Sync</value></param>
<param><key>label2</key><value>After Frame Sync</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>int(delay)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_noise</value></param>
<param><key>label</key><value>f_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>0.1</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"Frame"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>sym_rate</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"Frame"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>noise_voltage</key><value>noise</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>num_samps</key><value>128</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengths</key><value>2, 1024/8</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0</value></param>
<param><key>constellation_points</key><value>2</value></param>
<param><key>mod_code</key><value>"none"</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>(1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1 ,0,0,0)</value></param>
<param><key>tags</key><value>""</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>(255,255)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>data.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_delay</value></param>
<param><key>label</key><value>Delay</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>2*sps</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>bpsk_const</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk_const</value></param>
<param><key>sym_map</key><value>[0, 1]</value></param>
<param><key>const_points</key><value>[1+1j, -1-1j]</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>inets_frame_sync_cc</key>
<param><key>id</key><value>inets_frame_sync_cc_0</value></param>
<param><key>threshold</key><value>18</value></param>
<param><key>len_tag_key</key><value> "packet_len"</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>taps</key><value>rrc</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>0.06</value></param>
<param><key>order</key><value>2</value></param>
</block>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_frame_sync_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_frame_sync_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_1_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>digital_psk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_frame_sync_cc_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>inets_frame_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
