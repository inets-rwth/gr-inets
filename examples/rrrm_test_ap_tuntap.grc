<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rrrm_test_ap_tuntap</value></param>
<param><key>author</key><value>Julian Arnold</value></param>
<param><key>category</key><value>iNets</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>RRRM Test AP TUNTAP</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bpsk_mod</value></param>
<param><key>value</key><value>gnuradio.digital.constellation_bpsk().base()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>qpsk_mod</value></param>
<param><key>value</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_rx_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Rx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>range_rx_gain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tap0</value></param>
<param><key>mtu</key><value>1500</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>16</value></param>
<param><key>taps</key><value>[0.0035149301402270794, 0.0037406696937978268, 0.004412843845784664, 0.0055164373479783535, 0.007026799023151398, 0.008910189382731915, 0.011124536395072937, 0.013620376586914062, 0.016341954469680786, 0.019228478893637657, 0.0222154650837183, 0.02523619309067726, 0.028223179280757904, 0.031109705567359924, 0.033831287175416946, 0.03632712736725807, 0.038541484624147415, 0.04042487218976021, 0.04193523898720741, 0.04303883761167526, 0.043711014091968536, 0.04393675550818443, 0.043711014091968536, 0.04303883761167526, 0.04193523898720741, 0.04042487218976021, 0.038541484624147415, 0.03632712736725807, 0.033831287175416946, 0.031109705567359924, 0.028223179280757904, 0.02523619309067726, 0.0222154650837183, 0.019228478893637657, 0.016341954469680786, 0.013620376586914062, 0.011124536395072937, 0.008910189382731915, 0.007026799023151398, 0.0055164373479783535, 0.004412843845784664, 0.0037406696937978268, 0.0035149301402270794]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_1</value></param>
<param><key>decim</key><value>16</value></param>
<param><key>taps</key><value>[0.0035149301402270794, 0.0037406696937978268, 0.004412843845784664, 0.0055164373479783535, 0.007026799023151398, 0.008910189382731915, 0.011124536395072937, 0.013620376586914062, 0.016341954469680786, 0.019228478893637657, 0.0222154650837183, 0.02523619309067726, 0.028223179280757904, 0.031109705567359924, 0.033831287175416946, 0.03632712736725807, 0.038541484624147415, 0.04042487218976021, 0.04193523898720741, 0.04303883761167526, 0.043711014091968536, 0.04393675550818443, 0.043711014091968536, 0.04303883761167526, 0.04193523898720741, 0.04042487218976021, 0.038541484624147415, 0.03632712736725807, 0.033831287175416946, 0.031109705567359924, 0.028223179280757904, 0.02523619309067726, 0.0222154650837183, 0.019228478893637657, 0.016341954469680786, 0.013620376586914062, 0.011124536395072937, 0.008910189382731915, 0.007026799023151398, 0.0055164373479783535, 0.004412843845784664, 0.0037406696937978268, 0.0035149301402270794]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>inets_radio</key>
<param><key>id</key><value>inets_radio_0</value></param>
<param><key>constellation</key><value>qpsk_mod</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128[0:64]</value></param>
</block>
<block>
<key>inets_rrrm</key>
<param><key>id</key><value>inets_rrrm_0</value></param>
<param><key>channel_map</key><value>[0, 65]</value></param>
<param><key>node_id</key><value>0</value></param>
</block>
<block>
<key>inets_stop_and_wait_arq</key>
<param><key>id</key><value>inets_stop_and_wait_arq_0</value></param>
<param><key>ack_timeout</key><value>0.2</value></param>
<param><key>max_mtu</key><value>500</value></param>
<param><key>stat_update_interval</key><value>100000</value></param>
<param><key>use_ack</key><value>False</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Payload"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>tr_tag</key><value></value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Input</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Output</value></param>
<param><key>name</key><value>"Correlator"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>20000</value></param>
<param><key>srate</key><value>samp_rate / 4</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_level</key><value>20</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>"Magnitude"</value></param>
<param><key>ymax</key><value>80</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>rollingscope_scope</key>
<param><key>id</key><value>rollingscope_scope_0_0</value></param>
<param><key>full_scale</key><value>1</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>num_sp</key><value>2048</value></param>
<param><key>fs</key><value>samp_rate / (16*16)</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>RSSI</value></param>
<param><key>label1</key><value>Correlator</value></param>
<param><key>label2</key><value>Demod</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>2e9</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value>"packet_len"</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>1.5e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_1</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_1</source_block_id><sink_block_id>inets_rrrm_0</sink_block_id><source_key>pdus</source_key><sink_key>radar_in</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0</source_block_id><sink_block_id>inets_stop_and_wait_arq_0</sink_block_id><source_key>pdus</source_key><sink_key>from_app</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_1</source_block_id><sink_block_id>rollingscope_scope_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_radio_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_radio_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_radio_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_radio_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_radio_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_radio_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_radio_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_radio_0</source_block_id><sink_block_id>inets_rrrm_0</sink_block_id><source_key>out</source_key><sink_key>rrrm_in</sink_key></connection>
<connection><source_block_id>inets_radio_0</source_block_id><sink_block_id>inets_stop_and_wait_arq_0</sink_block_id><source_key>snr</source_key><sink_key>snr</sink_key></connection>
<connection><source_block_id>inets_rrrm_0</source_block_id><sink_block_id>inets_stop_and_wait_arq_0</sink_block_id><source_key>payload_out</source_key><sink_key>from_phy</sink_key></connection>
<connection><source_block_id>inets_rrrm_0</source_block_id><sink_block_id>inets_radio_0</sink_block_id><source_key>rrrm_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_stop_and_wait_arq_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0</sink_block_id><source_key>to_app</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>inets_stop_and_wait_arq_0</source_block_id><sink_block_id>inets_rrrm_0</sink_block_id><source_key>to_phy</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>inets_radio_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
